# Keil uVision project Blinky.uvprojx, settings and files
target STM32F103 RAM (5060960::V5.06 update 7 (build 960)::ARMCC)
  device: STM32F103ZE STMicroelectronics
  pack: Keil.STM32F1xx_DFP.2.4.1
  cpu: IROM(0x08000000,0x80000) IRAM(0x20000000,0x10000) CPUTYPE("Cortex-M3") CLOCK(72000000) ELITTLE
  output: Blinky
  c flags: Optim=1
  c define: VECT_TAB_SRAM
  library: MicroLIB
  memory RVCT4: ROM 0x20000000 size 0x8000
  memory RVCT9: RAM 0x20008000 size 0x8000
  group Source Files
    ./: Blinky.c Thread_ADC.c Thread_LED.c
  group Documentation
    ./: Abstract.txt
target STM32F103 Flash (6210000::V6.21::ARMCLANG)
  device: STM32F103ZE STMicroelectronics
  pack: Keil.STM32F1xx_DFP.2.4.1
  cpu: as above
  output: Blinky
  c flags: Optim=7 v6Lang=1 v6LangP=3 v6Lto=1
  memory RVCT4: ROM 0x8000000 size 0x80000
  memory RVCT9: RAM 0x20000000 size 0x10000
target STM32F103 Flash + ULP (5060960::V5.06 update 7 (build 960)::ARMCC)
  device: STM32F103ZE STMicroelectronics
  pack: Keil.STM32F1xx_DFP.2.4.1
  cpu: as above
  output: Blinky
  c flags: Optim=1
  memory RVCT4: ROM 0x8000000 size 0x80000
  memory RVCT9: RAM 0x20000000 size 0x10000
software components: CMSIS:CORE 5.6.0, CMSIS:CORE 6.0.0, CMSIS:RTOS:Keil RTX 4.79.0, CMSIS:RTOS:Keil RTX 4.82.0, Board Support:A/D Converter 2.0.0, Board Support:Buttons 2.0.0, Board Support:LED 2.0.0, Device:GPIO 1.3, Device:Startup 1.0.0
